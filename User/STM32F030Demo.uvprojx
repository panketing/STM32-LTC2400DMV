# Keil uVision project STM32F030Demo.uvprojx, settings and files
target Stm32f030demo (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: STM32F030Demo +hex
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\HARDWARE;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\User;..\SYSTEM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c HDQ.c GPIO_HDQ.c LQ12864.c LTC2400.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group HARDWARE
    ../HARDWARE/: led.c USART1.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c
